# IAR project Heater_Controller.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103K3 STM8S103K3
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.PreInclude: \Source\stm8s_conf.h
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; Source; STM8_SPI; SPL\src; SPL\inc; Strings; LCD; Delays; STM8_GPIO; STM8S_EEPROM
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Heater_Controller.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group Delays
    Delays/: STM8_Delays.c
  group LCD
    LCD/: LCDv1.c
  group Source
    Source/: main.c PID.c
  group SPL
    SPL/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c
  group STM8_EEPROM
    STM8S_EEPROM/: CRC.c STM8S_EEPROM.c
  group STM8_GPIO
    STM8_GPIO/: STM8_GPIO.c
  group STM8_SPI
    STM8_SPI/: STM8_SPI.c
  group Strings
    Strings/: strings.c
